// ======================================================================
//  OLED SSD1306 128×64 по I2C — свой минимальный драйвер, только текст.
//  Без буфера кадра (Adafruit занял бы 1 КБ из 2 КБ ОЗУ) и без сторонних
//  библиотек. Шрифт 5×7, выводится удвоенным: символ 12×16 точек
//  (10 символов в строке), как setTextSize(2) в CardTester.
// ======================================================================

#include "display.h"
#include <Wire.h>

#define OLED_ADDR 0x3C

// Классический шрифт 5×7, символы 0x20…0x7E, столбцы, младший бит — верх
static const uint8_t font5x7[] PROGMEM = {
  0x00,0x00,0x00,0x00,0x00, 0x00,0x00,0x5F,0x00,0x00, 0x00,0x07,0x00,0x07,0x00, 0x14,0x7F,0x14,0x7F,0x14, // ' ' ! " #
  0x24,0x2A,0x7F,0x2A,0x12, 0x23,0x13,0x08,0x64,0x62, 0x36,0x49,0x55,0x22,0x50, 0x00,0x05,0x03,0x00,0x00, // $ % & '
  0x00,0x1C,0x22,0x41,0x00, 0x00,0x41,0x22,0x1C,0x00, 0x14,0x08,0x3E,0x08,0x14, 0x08,0x08,0x3E,0x08,0x08, // ( ) * +
  0x00,0x50,0x30,0x00,0x00, 0x08,0x08,0x08,0x08,0x08, 0x00,0x60,0x60,0x00,0x00, 0x20,0x10,0x08,0x04,0x02, // , - . /
  0x3E,0x51,0x49,0x45,0x3E, 0x00,0x42,0x7F,0x40,0x00, 0x42,0x61,0x51,0x49,0x46, 0x21,0x41,0x45,0x4B,0x31, // 0 1 2 3
  0x18,0x14,0x12,0x7F,0x10, 0x27,0x45,0x45,0x45,0x39, 0x3C,0x4A,0x49,0x49,0x30, 0x01,0x71,0x09,0x05,0x03, // 4 5 6 7
  0x36,0x49,0x49,0x49,0x36, 0x06,0x49,0x49,0x29,0x1E, 0x00,0x36,0x36,0x00,0x00, 0x00,0x56,0x36,0x00,0x00, // 8 9 : ;
  0x08,0x14,0x22,0x41,0x00, 0x14,0x14,0x14,0x14,0x14, 0x00,0x41,0x22,0x14,0x08, 0x02,0x01,0x51,0x09,0x06, // < = > ?
  0x32,0x49,0x79,0x41,0x3E, 0x7E,0x11,0x11,0x11,0x7E, 0x7F,0x49,0x49,0x49,0x36, 0x3E,0x41,0x41,0x41,0x22, // @ A B C
  0x7F,0x41,0x41,0x22,0x1C, 0x7F,0x49,0x49,0x49,0x41, 0x7F,0x09,0x09,0x09,0x01, 0x3E,0x41,0x49,0x49,0x7A, // D E F G
  0x7F,0x08,0x08,0x08,0x7F, 0x00,0x41,0x7F,0x41,0x00, 0x20,0x40,0x41,0x3F,0x01, 0x7F,0x08,0x14,0x22,0x41, // H I J K
  0x7F,0x40,0x40,0x40,0x40, 0x7F,0x02,0x0C,0x02,0x7F, 0x7F,0x04,0x08,0x10,0x7F, 0x3E,0x41,0x41,0x41,0x3E, // L M N O
  0x7F,0x09,0x09,0x09,0x06, 0x3E,0x41,0x51,0x21,0x5E, 0x7F,0x09,0x19,0x29,0x46, 0x46,0x49,0x49,0x49,0x31, // P Q R S
  0x01,0x01,0x7F,0x01,0x01, 0x3F,0x40,0x40,0x40,0x3F, 0x1F,0x20,0x40,0x20,0x1F, 0x3F,0x40,0x38,0x40,0x3F, // T U V W
  0x63,0x14,0x08,0x14,0x63, 0x07,0x08,0x70,0x08,0x07, 0x61,0x51,0x49,0x45,0x43, 0x00,0x7F,0x41,0x41,0x00, // X Y Z [
  0x02,0x04,0x08,0x10,0x20, 0x00,0x41,0x41,0x7F,0x00, 0x04,0x02,0x01,0x02,0x04, 0x40,0x40,0x40,0x40,0x40, // \ ] ^ _
  0x00,0x01,0x02,0x04,0x00, 0x20,0x54,0x54,0x54,0x78, 0x7F,0x48,0x44,0x44,0x38, 0x38,0x44,0x44,0x44,0x20, // ` a b c
  0x38,0x44,0x44,0x48,0x7F, 0x38,0x54,0x54,0x54,0x18, 0x08,0x7E,0x09,0x01,0x02, 0x0C,0x52,0x52,0x52,0x3E, // d e f g
  0x7F,0x08,0x04,0x04,0x78, 0x00,0x44,0x7D,0x40,0x00, 0x20,0x40,0x44,0x3D,0x00, 0x7F,0x10,0x28,0x44,0x00, // h i j k
  0x00,0x41,0x7F,0x40,0x00, 0x7C,0x04,0x18,0x04,0x78, 0x7C,0x08,0x04,0x04,0x78, 0x38,0x44,0x44,0x44,0x38, // l m n o
  0x7C,0x14,0x14,0x14,0x08, 0x08,0x14,0x14,0x18,0x7C, 0x7C,0x08,0x04,0x04,0x08, 0x48,0x54,0x54,0x54,0x20, // p q r s
  0x04,0x3F,0x44,0x40,0x20, 0x3C,0x40,0x40,0x20,0x7C, 0x1C,0x20,0x40,0x20,0x1C, 0x3C,0x40,0x30,0x40,0x3C, // t u v w
  0x44,0x28,0x10,0x28,0x44, 0x0C,0x50,0x50,0x50,0x3C, 0x44,0x64,0x54,0x4C,0x44, 0x00,0x08,0x36,0x41,0x00, // x y z {
  0x00,0x00,0x7F,0x00,0x00, 0x00,0x41,0x36,0x08,0x00, 0x08,0x04,0x08,0x10,0x08,                           // | } ~
};

static bool present;

static void cmd(uint8_t c) {
  Wire.beginTransmission(OLED_ADDR);
  Wire.write(0x00);                                // поток команд
  Wire.write(c);
  Wire.endTransmission();
}

static void set_pos(uint8_t page, uint8_t col) {
  cmd(0xB0 | page);
  cmd(0x00 | (col & 0x0F));
  cmd(0x10 | (col >> 4));
}

// Данные порциями: буфер Wire — 32 байта
static void data(const uint8_t *d, uint8_t n) {
  while (n) {
    uint8_t k = n > 16 ? 16 : n;
    Wire.beginTransmission(OLED_ADDR);
    Wire.write(0x40);                              // поток данных
    Wire.write(d, k);
    Wire.endTransmission();
    d += k; n -= k;
  }
}

static void clear() {
  uint8_t z[16] = {0};
  for (uint8_t p = 0; p < 8; p++) {
    set_pos(p, 0);
    for (uint8_t i = 0; i < 128 / 16; i++) data(z, 16);
  }
}

// Растянуть 4 бита столбца в 8 (каждая точка — две по вертикали)
static uint8_t stretch(uint8_t n) {
  uint8_t r = 0;
  for (uint8_t i = 0; i < 4; i++)
    if (n & (1 << i)) r |= 3 << (2 * i);
  return r;
}

// Строка удвоенным шрифтом в страницах page, page+1
static void text2x(uint8_t page, const char *s) {
  uint8_t len = strlen(s);
  if (len > 10) len = 10;
  uint8_t col = (128 - len * 12) / 2;
  for (uint8_t half = 0; half < 2; half++) {
    set_pos(page + half, col);
    for (uint8_t i = 0; i < len; i++) {
      char c = s[i];
      if (c < 0x20 || c > 0x7E) c = '?';
      uint8_t out[12];
      for (uint8_t x = 0; x < 6; x++) {
        uint8_t bits = x < 5 ? pgm_read_byte(&font5x7[(c - 0x20) * 5 + x]) : 0;
        uint8_t v = stretch(half ? bits >> 4 : bits & 0x0F);
        out[2 * x] = out[2 * x + 1] = v;
      }
      data(out, 12);
    }
  }
}

void disp_init() {
  Wire.begin();
  Wire.setClock(400000L);
  Wire.beginTransmission(OLED_ADDR);
  present = Wire.endTransmission() == 0;           // без дисплея прошивка работает и так
  if (!present) return;
  static const uint8_t init_seq[] PROGMEM = {
    0xAE,             // выкл
    0xD5, 0x80,       // частота
    0xA8, 0x3F,       // 64 строки
    0xD3, 0x00,       // смещение
    0x40,             // начальная строка 0
    0x8D, 0x14,       // накачка включена
    0x20, 0x02,       // страничная адресация
    0xA1, 0xC8,       // ориентация (повернуть на 180°: 0xA0, 0xC0)
    0xDA, 0x12,       // конфигурация COM
    0x81, 0xCF,       // контраст
    0xD9, 0xF1,       // предзаряд
    0xDB, 0x40,       // VCOMH
    0xA4, 0xA6,       // из ОЗУ, без инверсии
    0xAF,             // вкл
  };
  for (uint8_t i = 0; i < sizeof(init_seq); i++) cmd(pgm_read_byte(&init_seq[i]));
  clear();
}

void disp_screen(const char *l1, const char *l2, const char *l3) {
  if (!present) return;
  clear();
  if (l1) text2x(0, l1);
  if (l2) text2x(3, l2);
  if (l3) text2x(6, l3);
}
